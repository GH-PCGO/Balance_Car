# Keil uVision project gd32balance.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32balance +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F4xx\Include;.\Firmware\GD32F4xx_standard_peripheral\Include;.\User;.\Hardware\led;.\Hardware\battery;.\Hardware\dma_recv;.\Hardware\ws2812;.\Hardware\motor;.\Hardware\encoder;.\Hardware\iic;.\Hardware\mpu6050;.\Hardware\mpu6050\eMPL;.\Hardware\bluethooth;.\Hardware\data_show;.\Hardware\protocol;.\Hardware;.\Hardware\Ultrasonic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: gd32f4xx_it.c main.c systick.c
  group Firmware
    ./Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ./Hardware/led/: led.c
    ./Hardware/battery/: battery.c
    ./Hardware/dma_recv/: bsp_dma_recv.c
    ./Hardware/ws2812/: ws2812.c
    ./Hardware/motor/: motor.c
    ./Hardware/encoder/: encoder.c
    ./Hardware/mpu6050/: mpu6050.c
    ./Hardware/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Hardware/iic/: i2c.c
    ./Hardware/bluethooth/: bluetooth.c
    ./Hardware/data_show/: data_show.c
    ./Hardware/protocol/: protocol.c
    ./Hardware/Ultrasonic/: Ultrasonic.c
